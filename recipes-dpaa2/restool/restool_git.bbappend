COMPATIBLE_MACHINE_nxp-lx2xxx = "nxp-lx2xxx"

SRC_URI_nxp-lx2xxx = "git://source.codeaurora.org/external/qoriq/qoriq-components/restool;nobranch=1"
SRCREV_nxp-lx2xxx = "fe31ebb09cf8d153042d32efd3e370fd0e2ff318"
