require linux-yocto-nxp-lx2xxx.inc

KBRANCH_nxp-lx2xxx  = "standard/preempt-rt/nxp-ls/lsdk-1712/${KMACHINE}"
