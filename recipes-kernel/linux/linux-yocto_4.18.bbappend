require linux-yocto-nxp-lx2xxx.inc

KBRANCH_nxp-lx2xxx  = "v4.18/standard/nxp-ls/lsdk-1906/${KMACHINE}"
